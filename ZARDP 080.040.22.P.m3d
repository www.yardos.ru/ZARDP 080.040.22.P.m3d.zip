# KOMPAS-3D part (ZARDP 080.040.22.P.m3d)

Model tree:
1. Операция без истории:1
2. Операция без истории:2

Texts:
  ЗАРДП 080.040.22-ХХ.Р
  Кран шаровой фланцевый
  ООО "ИК Энерпред-Ярдос"